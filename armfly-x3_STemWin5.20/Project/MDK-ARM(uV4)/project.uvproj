# Keil uVision project project.uvproj, settings and files
target Flash (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: output
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,ARM_MATH_CM4,__CC_ARM
  c misc: --diag_suppress=870
  c include: ..\..\User;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\User\fonts;..\..\emWin\GUI_X;..\..\emWin\Config;..\..\emWin\Include;..\..\emWin\emWinTask;..\..\User\fatfs\src;..\..\FreeRTOS\include;..\..\FreeRTOS\portable\RVDS\ARM_CM4F;..\..\User\bsp_stm32f4xx;..\..\User\bsp_stm32f4xx\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../../User/: main.c
    ../../User/bsp_stm32f4xx/: stm32f4xx_it.c
  group BSP
    ../../User/bsp_stm32f4xx/src/: bsp_uart.c bsp_fsmc_sram.c bsp_key.c bsp_led.c bsp_printf.c bsp_sdio_sd.c bsp_timer.c bsp_time_measure.c
    ../../User/bsp_stm32f4xx/: bsp.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_syscfg.c misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_iwdg.c stm32f4xx_tim.c stm32f4xx_wwdg.c stm32f4xx_crc.c stm32f4xx_spi.c stm32f4xx_fsmc.c stm32f4xx_sdio.c stm32f4xx_dma.c
  group CMSIS
    ../../User/bsp_stm32f4xx/: system_stm32f4xx.c
  group DSP_Lib
    ../../Libraries/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group LCD_Driver
    ../../User/bsp_stm32f4xx/src/: bsp_tft_lcd.c bsp_touch.c LCD_SPFD5420.c LCD_RA8875.c
    ../../emWin/DisplayDriver/: GUIDRV_Template.c
  group fonts
    ../../User/fonts/: asc12.c asc16.c fonts.h hz12.c hz16.c hzk12s.c hzk16fs.c hzk16s.c hzk24h.c hzk24k.c hzk24s.c SimSun_1616.c SimSun_2424.c
  group GUI_X
    ../../emWin/GUI_X/: GUI_X_Touch_Analog.c GUI_VNC_X.c GUI_X_Touch_StoreState.c GUI_X.c
  group GUI/Config
    ../../emWin/Config/: GUIConf.c GUIConf.h LCDConf.c LCDConf.h
  group GUI/DEMO
    ../../emWin/emWinTask/: MainTask.c
  group GUI/Lib
    ../../emWin/GUILib/: STemWin520d_CM4_Keil.lib
target CpuRAM (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: output
  AfterMake: CopyHex_CpuRAM.bat
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,ARM_MATH_CM4,__CC_ARM,VECT_TAB_SRAM
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\User\bsp;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x8000
  memory RVCT9: RAM 0x20008000 size 0x8000
target ExtSRAM (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: output +hex
  AfterMake: CopyHex_ExtSRAM.bat
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER,VECT_TAB_SRAM
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\User\bsp;..\..\User
  library: MicroLIB
  memory RVCT4: ROM 0x68000000 size 0x80000
  memory RVCT9: RAM 0x20000200 size 0xffe00
