# Keil uVision project graduation project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: graduation project +hex
  c flags: Optim=1
  c include: ..\library\cmsis;..\library\fwlib\inc;..\user;..\user\API;..\Gui;..\Gui\ZLG_GUI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group fwlib
    ../library/fwlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group cmsis
    ../library/cmsis/: core_cm3.c core_cm3.h
  group user
    ../user/: main.c stm32f10x_it.c system_stm32f10x.c
    ../user/API/: led.c lcd.C sys_tick.c zi.c flash.c uart.c exti.c key.c rtc.c
  group startup
    ./: startup_stm32f10x_hd.s
